# Keil uVision project WW-RT-Thread.uvproj, settings and files
target Target 1 (MCS-51)
  device: Nexar TSK51 Altium
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF) CLOCK(44000000)
  output: WW-RT-Thread
  c flags: Optimize=8 SizeSpeed=1
  asm include: ..\RT-Thread-软件仿真\User
  group user
    ../RT-Thread-软件仿真/User/: main.c
  group rtt/source
    ../RT-Thread-软件仿真/rtthread/3.0.3/include/libc/: rtdef.h
  group doc
    ../RT-Thread-软件仿真/Doc/: readme.txt
